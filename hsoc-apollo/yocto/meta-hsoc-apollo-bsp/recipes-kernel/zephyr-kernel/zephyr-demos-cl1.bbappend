#
# SPDX-License-Identifier: MIT
#

# Apollo FVP reuses the RD-Aspen Safety Island Zephyr board until
# Apollo-specific Safety Island board metadata is introduced.
ZEPHYR_BOARD:apollo-fvp = "fvp_rd_aspen_safety_island_c1"
